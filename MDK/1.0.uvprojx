# Keil uVision project 1.0.uvprojx, settings and files
target Project (5050106::V5.05 update 1 (build 106)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: 1.0 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_MD
  c include: ..\User\APP;..\User\BSP;..\Library\CMSIS\CoreSupport;..\Library\CMSIS\DeviceSupport\ST\STM32F10x;..\Library\STM32F10x_StdPeriph_Driver\inc;..\Library\STM32F10x_StdPeriph_Driver\src
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group StarUp
    ../Library/CMSIS/DeviceSupport/Startup/: startup_stm32f10x_md.s
  group Library
    ../Library/CMSIS/CoreSupport/: core_cm3.c
    ../Library/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c stm32f10x_bkp.c stm32f10x_pwr.c stm32f10x_rtc.c stm32f10x_tim.c stm32f10x_i2c.c stm32f10x_flash.c stm32f10x_adc.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_fsmc.c stm32f10x_iwdg.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_wwdg.c
  group System
    ../User/APP/: main.c stm32f10x_it.c
    ../Library/CMSIS/DeviceSupport/: system_stm32f10x.c
  group User_APP
    ../User/APP/: Tasks.c
  group User_BSP
    ../User/BSP/: Usart.c Sys.c Key.c Delay.c Timer.c
